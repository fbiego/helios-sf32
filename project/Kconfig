## project/Kconfig
```kconfig
# Kconfig root for Helios SF32.
source "$SIFLI_SDK/Kconfig.v2"
rsource "Kconfig.proj"
```
